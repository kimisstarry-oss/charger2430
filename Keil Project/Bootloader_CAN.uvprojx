# Keil uVision project Bootloader_CAN.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MM32F0144C6P MindMotion
  pack: MindMotion.MM32F0140_DFP.1.2.2
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Bootloader_CAN +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Device;..\User;..\Device\CMSIS\KEIL_Core;..\Device\MM32F0140\Include;..\Device\MM32F0140\HAL_Lib\Inc;..\Device\MM32F0140\HAL_Lib\Src;..\Device\MM32F0140\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group USER
    ../User/: main.c bootloader.c bootloader.h can.c can.h can_receive.c can_receive.h
  group STARTUP
    ../Device/MM32F0140/Source/KEIL_StartAsm/: startup_mm32f0140_keil.s
    ../Device/MM32F0140/Source/: system_mm32f0140.c
  group HALlib
    ../Device/MM32F0140/HAL_Lib/Src/: hal_adc.c hal_comp.c hal_crc.c hal_dbg.c hal_div.c hal_dma.c hal_exti.c hal_flash.c hal_flexcan.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_misc.c hal_pwr.c hal_rcc.c hal_spi.c hal_sqrt.c hal_tim.c hal_uart.c hal_uid.c hal_ver.c hal_wwdg.c
